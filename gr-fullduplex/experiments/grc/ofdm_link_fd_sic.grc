options:
  parameters:
    generate_options: qt_gui
    id: ofdm_link_fd_gui
    output_language: python
  states: {}

blocks:
- name: delay_tx2rx
  id: variable
  parameters:
    value: '51'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: int(((packet_len+4)/12+3+2 + 2 + 2*2)*80 )
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: occupied_carriers_len
  id: variable
  parameters:
    value: len(occupied_carriers[0])
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pad_front_len
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: pad_tail_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_carriers_len
  id: variable
  parameters:
    value: len(pilot_carriers[0])
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: pilot_symbols_len
  id: variable
  parameters:
    value: len(pilot_symbols[0])
  states: {}
- name: premultiply
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: symbols_num
  id: variable
  parameters:
    value: (packet_len + 4)*8/2 /occupied_carriers_len + 3
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: sync_word_len
  id: variable
  parameters:
    value: len(sync_word)
  states: {}
- name: sync_word_zero_len
  id: variable
  parameters:
    value: len(sync_word_zeros)
  states: {}
- name: sync_word_zeros
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0] '
  states: {}
- name: usrp_sink_addr
  id: variable
  parameters:
    value: '"addr0=192.168.50.2"'
  states: {}
- name: usrp_source_addr
  id: variable
  parameters:
    value: '"addr0=192.168.50.2"'
  states: {}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(5.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_1
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(5.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_1_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_2
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: frame_len + pad_front_len + pad_tail_len
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: frame_len + pad_front_len + pad_tail_len
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: Rx Packets
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: byte
    vector: '[4, 4, 4 , 4, 0, 0, 0, 0]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: byte
    vector: '[0, 1, 2, 3, 4, 3, 2, 1]'
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    minoutbuf: out_buf_size
    occupied_carriers: occupied_carriers
    packet_len_key: '"rx_len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_rx_0_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    minoutbuf: out_buf_size
    occupied_carriers: occupied_carriers
    packet_len_key: '"rx_len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: fullduplex_digital_sic_0
  id: fullduplex_digital_sic
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: frame_len
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    premultiplier: premultiply
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '0'
  states: {}
- name: fullduplex_digital_sic_0_0
  id: fullduplex_digital_sic
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: frame_len
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    premultiplier: premultiply
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '1'
  states: {}
- name: fullduplex_packet_encap2_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    pad_tail: pad_tail_len
    premultiplier: premultiply
    sig_pilot_pos: '0'
    sync_word: '1'
  states: {}
- name: fullduplex_packet_encap2_0_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    pad_tail: pad_tail_len
    premultiplier: premultiply
    sig_pilot_pos: '1'
    sync_word: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    label1: '"Radio 1"'
    label2: '"Radio 2"'
    nconnections: '2'
    showports: 'True'
    type: complex
    width1: '2'
    width2: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: tab@0
    label1: '"Radio 1"'
    label2: '"Radio 2"'
    name: Scope Plot
    nconnections: '2'
    size: packet_len
    srate: samp_rate
    type: float
    update_time: '0.1'
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab@2
    label1: Est. h for FD node 0 - I
    label2: Est. h for FD node 0 - Q
    label3: Est. h for FD node 1 - I
    label4: Est. h for FD node 1 - Q
    marker1: '0'
    marker2: '0'
    marker3: '0'
    marker4: '0'
    nconnections: '2'
    size: 21 * 1
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: '0.20'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Rx Packets
    label1: Rx Signal Spectr
    label2: Estimated Digital Taps
    num_tabs: '3'
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dev_addr: usrp_sink_addr
    dev_args: '""'
    gain0: '10'
    gain1: '10'
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: usrp_source_addr
    dev_args: '""'
    gain0: '10'
    gain1: '10'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_stream1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_stream0
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', fullduplex_packet_encap2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fullduplex_packet_encap2_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_ofdm_tx_0_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', fullduplex_digital_sic_0, '1']
- [blocks_stream_to_tagged_stream_1_0, '0', fullduplex_digital_sic_0_0, '1']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_0_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_tx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fullduplex_digital_sic_0, '0', blocks_null_sink_0_0_0, '0']
- [fullduplex_digital_sic_0, '1', digital_ofdm_rx_0_0, '0']
- [fullduplex_digital_sic_0, '1', qtgui_freq_sink_x_0, '0']
- [fullduplex_digital_sic_0, '2', qtgui_time_sink_x_1, '0']
- [fullduplex_digital_sic_0_0, '0', blocks_null_sink_0_0_0, '1']
- [fullduplex_digital_sic_0_0, '1', digital_ofdm_rx_0_0_0, '0']
- [fullduplex_digital_sic_0_0, '1', qtgui_freq_sink_x_0, '1']
- [fullduplex_digital_sic_0_0, '2', qtgui_time_sink_x_1, '1']
- [fullduplex_packet_encap2_0, '0', uhd_usrp_sink, '0']
- [fullduplex_packet_encap2_0, '0', virtual_sink_0, '0']
- [fullduplex_packet_encap2_0_0, '0', uhd_usrp_sink, '1']
- [fullduplex_packet_encap2_0_0, '0', virtual_sink_0_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_tagged_stream_1, '0']
- [uhd_usrp_source, '1', blocks_stream_to_tagged_stream_1_0, '0']
- [virtual_source_0, '0', fullduplex_digital_sic_0_0, '0']
- [virtual_source_1, '0', fullduplex_digital_sic_0, '0']

metadata:
  file_format: 1
