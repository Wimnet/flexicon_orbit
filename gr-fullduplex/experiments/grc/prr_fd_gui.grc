options:
  parameters:
    generate_options: qt_gui
    id: prr_fd_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bb_gain
  id: variable
  parameters:
    value: '-21.5'
  states: {}
- name: delay_tx2rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,6
    label: Delay Tx2Rx
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '52'
  states: {state: disabled}
- name: delay_tx2rx
  id: variable
  parameters:
    value: '58'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: int(((packet_len+4)/12+3+2 + 2 + 2*2)*80  + 0*80)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: ((-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26),)
  states: {}
- name: occupied_carriers_len
  id: variable
  parameters:
    value: len(occupied_carriers[0])
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pad_front_len
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: pad_tail_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_carriers_len
  id: variable
  parameters:
    value: len(pilot_carriers[0])
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: pilot_symbols_len
  id: variable
  parameters:
    value: len(pilot_symbols[0])
  states: {}
- name: premultiply
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: symbols_num
  id: variable
  parameters:
    value: (packet_len + 4)*8/2 /occupied_carriers_len + 3
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: sync_word_len
  id: variable
  parameters:
    value: len(sync_word)
  states: {}
- name: sync_word_zero_len
  id: variable
  parameters:
    value: len(sync_word_zeros)
  states: {}
- name: sync_word_zeros
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0] '
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,6
    label: Tx Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '20'
  states: {}
- name: usrp_sink_addr
  id: variable
  parameters:
    value: '"addr0=192.168.50.2"'
  states: {}
- name: usrp_source_addr
  id: variable
  parameters:
    value: '"addr0=192.168.50.2"'
  states: {}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(5.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_1
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(5.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_1_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_2
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '50'
    min: '0'
    num_samps: '50'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '100'
    min: '51'
    num_samps: '50'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply * 10 ** (-5.0/20)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply * 10**(bb_gain/20.0)
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_3_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_null_sink_3_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_3_1_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: frame_len + pad_front_len + pad_tail_len
    type: complex
  states: {}
- name: digital_ofdm_rx_0_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    minoutbuf: out_buf_size
    occupied_carriers: occupied_carriers
    packet_len_key: '"rx_len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: fullduplex_async_divide_0
  id: fullduplex_async_divide
  parameters: {}
  states: {}
- name: fullduplex_count_packets_0
  id: fullduplex_count_packets
  parameters:
    debug: 'False'
  states: {}
- name: fullduplex_count_packets_0_0
  id: fullduplex_count_packets
  parameters:
    debug: 'False'
  states: {}
- name: fullduplex_digital_sic_0_0
  id: fullduplex_digital_sic
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: frame_len
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    premultiplier: premultiply
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '0'
  states: {}
- name: fullduplex_ofdm_constellation_0
  id: fullduplex_ofdm_constellation
  parameters:
    debug: 'False'
    delay_tx2rx: '0'
    minoutbuf: out_buf_size
    packet_len: frame_len
    pad_front: '-20'
  states: {}
- name: fullduplex_ofdm_constellation_0_0
  id: fullduplex_ofdm_constellation
  parameters:
    debug: 'False'
    delay_tx2rx: '8'
    minoutbuf: out_buf_size
    packet_len: frame_len
    pad_front: '-20'
  states: {}
- name: fullduplex_packet_encap2_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    pad_tail: pad_tail_len
    premultiplier: premultiply
    sig_pilot_pos: '0'
    sync_word: '2'
  states: {}
- name: fullduplex_packet_encap2_0_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    pad_tail: pad_tail_len
    premultiplier: '0.2'
    sig_pilot_pos: '1'
    sync_word: '2'
  states: {}
- name: fullduplex_snr_calc_0
  id: fullduplex_snr_calc
  parameters:
    data_symbols: '6'
    debug: 'False'
    delay_tx2rx: '0'
    noise_length: '140'
    noise_start_idx: '0'
    pad_front: '-20'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3, 7, 3, 3
    name: '"Constellation after Digital SIC"'
    size: 3*48
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0, 7, 3, 3
    name: '"Constellation after RF SIC"'
    size: 3*48
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,6
    label1: '"Signal-to-Noise Ratio"'
    max: '35'
    min: '0'
    name: '"Measured SNR"'
    type: float
    unit1: '"dB"'
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,6
    max: '35'
    min: '0'
    name: '"Transmitted Packets"'
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,6
    max: '35'
    min: '0'
    name: '"Received Packets"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 4,0,1,6
    label1: '"Packet Reception  Ratio"'
    min: '0'
    name: '"Measured PRR"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,3,6
    label1: '"After RF SIC, I"'
    label2: '"After RF SIC, Q"'
    label3: '"After Digital SIC, I"'
    label4: '"After Digital SIC, Q"'
    nconnections: '2'
    size: frame_len
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dev_addr: usrp_sink_addr
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dev_addr: usrp_source_addr
    dev_args: '""'
    gain0: '10'
    gain1: '10'
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fd_tx_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fd_tx_stream
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_random_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_null_sink_3_1_1, '0']
- [blocks_float_to_uchar_0, '0', fullduplex_count_packets_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', fullduplex_packet_encap2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', fullduplex_packet_encap2_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_ofdm_tx_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_null_sink_3_1_1, '1']
- [blocks_stream_to_tagged_stream_0_0_0, '0', fullduplex_count_packets_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', fullduplex_digital_sic_0_0, '1']
- [digital_ofdm_rx_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_tx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fullduplex_async_divide_0, '0', qtgui_number_sink_0_0_0_0_0, '0']
- [fullduplex_count_packets_0, out, fullduplex_async_divide_0, in1]
- [fullduplex_count_packets_0_0, out, fullduplex_async_divide_0, in2]
- [fullduplex_digital_sic_0_0, '0', fullduplex_ofdm_constellation_0_0, '0']
- [fullduplex_digital_sic_0_0, '0', qtgui_time_sink_x_0, '0']
- [fullduplex_digital_sic_0_0, '1', blocks_complex_to_arg_0, '0']
- [fullduplex_digital_sic_0_0, '1', digital_ofdm_rx_0_0_0, '0']
- [fullduplex_digital_sic_0_0, '1', fullduplex_ofdm_constellation_0, '0']
- [fullduplex_digital_sic_0_0, '1', fullduplex_snr_calc_0, '0']
- [fullduplex_digital_sic_0_0, '1', qtgui_time_sink_x_0, '1']
- [fullduplex_digital_sic_0_0, '2', blocks_null_sink_3_1_0, '0']
- [fullduplex_ofdm_constellation_0, '0', qtgui_const_sink_x_0, '0']
- [fullduplex_ofdm_constellation_0, '1', blocks_null_sink_3_1, '1']
- [fullduplex_ofdm_constellation_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [fullduplex_ofdm_constellation_0_0, '1', blocks_null_sink_3_1, '0']
- [fullduplex_packet_encap2_0, '0', uhd_usrp_sink, '0']
- [fullduplex_packet_encap2_0, '0', virtual_sink_0, '0']
- [fullduplex_packet_encap2_0_0, '0', uhd_usrp_sink, '1']
- [fullduplex_snr_calc_0, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_tagged_stream_1, '0']
- [uhd_usrp_source, '1', blocks_null_sink_1, '0']
- [virtual_source_0, '0', fullduplex_digital_sic_0_0, '0']

metadata:
  file_format: 1
