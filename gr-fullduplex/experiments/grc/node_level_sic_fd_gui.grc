options:
  parameters:
    generate_options: qt_gui
    id: node_level_sic_fd_gui
    output_language: python
  states: {}

blocks:
- name: att_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '127'
    value: '127'
  states: {}
- name: att_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '127'
    value: '127'
  states: {}
- name: att_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '127'
    value: '0'
  states: {}
- name: canc_path
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: cap_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '6'
  states: {}
- name: cap_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '9'
  states: {}
- name: cap_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: cf_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '14'
  states: {}
- name: cf_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: dac_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '165'
  states: {}
- name: dac_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '195'
  states: {}
- name: dac_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '0'
  states: {}
- name: delay_tx2rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '51'
  states: {}
- name: delay_tx2rx
  id: variable
  parameters:
    value: 35+25
  states: {state: disabled}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: int(((packet_len+4)/12+3 +2+2+ 2*2)*80)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: ((-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26),)
  states: {}
- name: occupied_carriers_len
  id: variable
  parameters:
    value: len(occupied_carriers[0])
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 80-48
  states: {}
- name: pad_front_len
  id: variable
  parameters:
    value: 20000*2
  states: {}
- name: pad_tail_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_carriers_len
  id: variable
  parameters:
    value: len(pilot_carriers[0])
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: pilot_symbols_len
  id: variable
  parameters:
    value: len(pilot_symbols[0])
  states: {}
- name: premultiply
  id: variable
  parameters:
    value: '1'
  states: {}
- name: qf_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '2'
  states: {}
- name: qf_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '31'
    value: '2'
  states: {}
- name: rx_cal
  id: variable
  parameters:
    value: 0.00263936832236572983 * 8.91250938133745529953
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sub20_sn
  id: variable
  parameters:
    value: '"552C"'
  states: {}
- name: subdev_spec
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: symbols_num
  id: variable
  parameters:
    value: (packet_len + 4)*8/2 /occupied_carriers_len + 3
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: sync_word_len
  id: variable
  parameters:
    value: len(sync_word)
  states: {}
- name: sync_word_zero_len
  id: variable
  parameters:
    value: len(sync_word_zeros)
  states: {}
- name: sync_word_zeros
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0] '
  states: {}
- name: tx_cal
  id: variable
  parameters:
    value: 0.08570378452303695884 * 5.62341325190349080395
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: usrp_sink_addr
  id: variable
  parameters:
    value: '"addr0=192.168.50.2"'
  states: {}
- name: usrp_source_addr
  id: variable
  parameters:
    value: '"addr0=192.168.50.2"'
  states: {}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(5.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_0_1
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(5.0)
    function_name: set_start_time
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_1_0
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: variable_function_probe_0_2
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink
    function_args: uhd.time_spec_t(0.0)
    function_name: set_time_now
    poll_rate: '1e-9'
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '50'
    min: '0'
    num_samps: '50'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: tx_gain - 10
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1*(tx_gain - 10)'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_cal
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_cal
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '19.95262314968879601352'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '19.95262314968879601352'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: out_buf_size
    packet_len: frame_len + pad_front_len + pad_tail_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(64)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(64)
  states: {state: disabled}
- name: fullduplex_digital_sic_0
  id: fullduplex_digital_sic
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: frame_len
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    premultiplier: premultiply
    si_chan_dim: '1'
    si_chan_k: '10'
    sig_pilot_pos: '0'
  states: {}
- name: fullduplex_fde_config_0
  id: fullduplex_fde_config
  parameters:
    att_0_val: att_0
    att_1_val: att_1
    att_2_val: att_2
    canc_path_val: canc_path
    cf_0_val: cf_0
    cf_1_val: cf_1
    dac_0_val: dac_0
    dac_1_val: dac_1
    dac_2_val: dac_2
    init_cap_addr: '0'
    init_cap_val: '0'
    qf_0_val: qf_0
    qf_1_val: qf_1
    sn_val: sub20_sn
    tuner_cap_0_val: '0'
    tuner_cap_1_val: '0'
    tuner_cap_2_val: '0'
  states: {}
- name: fullduplex_packet_encap2_0
  id: fullduplex_packet_encap2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: pad_front_len
    pad_tail: pad_tail_len
    premultiplier: premultiply
    sig_pilot_pos: '0'
    sync_word: '2'
  states: {}
- name: fullduplex_parse_stream_sync_1
  id: fullduplex_parse_stream_sync
  parameters:
    debug: 'False'
    delay_tx2rx: delay_tx2rx
    frame_len: '320'
    minoutbuf: out_buf_size
    pad_front: pad_front_len
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    label1: '"SI after Circ. + RF Canc."'
    label2: '"SI after Circ. + RF + Digital Canc."'
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.50'
    width1: '2'
    width2: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@3
    label1: RF SIC
    label2: Rx power before digital SIC
    label3: Tx power
    nconnections: '3'
    size: '64'
    srate: samp_rate
    type: float
    width1: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: tab@0
    label1: '"SI after Circ. + RF Canc. - I"'
    label2: '"SI after Circ. + RF Canc. - Q"'
    label3: '"SI after Circ. + RF Canc. + Digital Canc. - I"'
    label4: '"SI after Circ. + RF Canc. + Digital Canc. - Q"'
    name: Scope Plot
    nconnections: '2'
    size: frame_len
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: '0.50'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@2
    label1: '"Digital Canc. Tap - I"'
    label2: '"Digital Canc. Tap - Q"'
    marker1: '0'
    marker2: '0'
    size: 21 * 1
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,3
    label0: Rx Packets
    label1: Rx Signal Spectr
    label2: Estimated Digital Taps
    label3: SI Channel
    num_tabs: '4'
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: usrp_sink_addr
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: subdev_spec
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_addr: usrp_source_addr
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: subdev_spec
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_stream0
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx_stream0
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_magphase_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_complex_to_magphase_0_1, '1', blocks_null_sink_0_1, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_const_vxx_0, '0', fullduplex_packet_encap2_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_magphase_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_divide_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_2_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_nlog10_ff_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_nlog10_ff_0_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', fullduplex_digital_sic_0, '1']
- [blocks_stream_to_tagged_stream_1, '0', fullduplex_parse_stream_sync_1, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fullduplex_digital_sic_0, '0', blocks_multiply_const_vxx_2, '0']
- [fullduplex_digital_sic_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fullduplex_digital_sic_0, '1', blocks_multiply_const_vxx_2_0, '0']
- [fullduplex_digital_sic_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [fullduplex_digital_sic_0, '2', qtgui_time_sink_x_1, '0']
- [fullduplex_packet_encap2_0, '0', uhd_usrp_sink, '0']
- [fullduplex_packet_encap2_0, '0', virtual_sink_0, '0']
- [fullduplex_parse_stream_sync_1, '0', blocks_stream_to_vector_0, '0']
- [fullduplex_parse_stream_sync_1, '1', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_tagged_stream_1, '0']
- [virtual_source_0, '0', fullduplex_parse_stream_sync_1, '0']
- [virtual_source_0_0, '0', fullduplex_digital_sic_0, '0']

metadata:
  file_format: 1
