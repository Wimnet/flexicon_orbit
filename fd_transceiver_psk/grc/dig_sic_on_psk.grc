<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dig_sic_on_psk</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>"0011110011100011000001111111"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ex_bw</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fd_message_display</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_usrp_in</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"usrp_in"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_usrp_out</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"usrp_out"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>20e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frames</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>power_ratio_display</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pream_size</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rem_signal</value></param>
<param><key>value</key><value>-55</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_message</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"This is a message from the remote radio"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_pay_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>len(rx_message) + len(' (000000000)\n') </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_delay</value></param>
<param><key>value</key><value>29</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0_0_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>rx_pay_len</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0_0_0</value></param>
<param><key>delay</key><value>usrp_delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>./usrp_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>./usrp_out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>10 ** ((rem_signal + 35 )* 50e-3)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_psk_demod</key>
<param><key>id</key><value>digital_psk_demod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>ex_bw</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>constellation</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>4</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>func_desired_msg</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr


class rx_fd_message(gr.sync_block):
    def __init__(self, message="rx_message"):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='FD Message',
            in_sig=[],
            out_sig=[np.uint8]
        )

        self.message = message
        self.message_size = len(self.message + ' (000000000)\n')

        self.count = 1
        self.message_count = 0

    def work(self, input_items, output_items):

        out_size = len(output_items[0])
        zeros_num = out_size % self.message_size
        char_num = out_size - zeros_num
        messages_num = char_num / self.message_size

        for i in range(0, messages_num):
            zeros = '0' * (9 - len(str(self.count)))
            m = self.message + ' (' + zeros + str(self.count) + ')\n'
            output_items[0][self.message_size * i:self.message_size * (i + 1)] = bytearray(m)
            self.count += 1

        output_items[0][self.message_size * (i + 1):] = np.zeros(zeros_num)

        return len(output_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>message</key><value>rx_message</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>func_dig_sic</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import time


class sic(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    def __init__(self, frame_size=5000, preamble_size=600, k=30, frames=500, error_report=1, warning_report=0, information_report=0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Digital SIC',   # will show up in GRC
            in_sig=[np.complex64, np.complex64],
            out_sig=[np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

        if frame_size &lt;= preamble_size:
            print 'Error: Frame must be &gt; Preamble !'
            exit(1)

        if preamble_size &lt;= 2 * k:
            print 'Error: Preamble must be &gt; 2k !'
            exit(1)

        self.fs = int(frame_size)
        self.p = int(preamble_size)
        self.k = int(k)
        self.er = bool(error_report)
        self.wr = bool(warning_report)
        self.ir = bool(information_report)

        self.in0_buff = []
        self.in1_buff = []
        self.out_buff = []
        self.out_num = 0
        self.first = 1
        self.h = np.zeros(2 * k)
        self.f = int(frames)
        self.fc = 0
        self.h_time = 0
        self.data_time = 0

    def work(self, input_items, output_items):

        t = time.time()

        self.in0_buff = np.append(self.in0_buff, input_items[0])
        self.in1_buff = np.append(self.in1_buff, input_items[1])
        in_size = min(len(self.in0_buff), len(self.in1_buff))

        if in_size &gt;= self.fs + 2 * self.k and not(self.first):  # not the first frame
            if self.fc % self.f == 0:
                # find h
                h_time = time.time()
                self.h = find_h_np(self.k, self.p, self.in0_buff[: self.k + self.fs], self.in1_buff[: self.k + self.fs], self.wr)
                h_time = time.time() - h_time
                if h_time &gt; self.h_time and self.ir:
                    self.h_time = h_time
                    print 'h time', self.h_time
            # calc the output
            data_time = time.time()
            A = build_A(self.in1_buff[: self.fs + 2 * self.k], self.k)
            self.out_buff = np.append(self.out_buff, self.in0_buff[self.k: self.k + self.fs] - np.dot(A, self.h))
            data_time = time.time() - data_time
            if data_time &gt; self.data_time and self.ir:
                self.data_time = data_time
                print 'data time', self.data_time
            self.out_num += self.fs
            self.in0_buff = self.in0_buff[self.fs:]  # keep last 2k samples for next time
            self.in1_buff = self.in1_buff[self.fs:]  # keep last 2k samples for next time
            self.fc += 1

        elif in_size &gt;= self.fs + self.k and self.first:  # the first frame
            if self.fc % self.f == 0:
                # find h
                h_time = time.time()
                self.h = find_h_np(self.k, self.p, self.in0_buff[: self.fs], self.in1_buff[: self.fs], self.wr)
                h_time = time.time() - h_time
                if h_time &gt; self.h_time and self.ir:
                    self.h_time = h_time
                    print 'h time', self.h_time
            # calc the output
            data_time = time.time()
            A = build_A(self.in1_buff[: self.fs + self.k], self.k)
            data_time = time.time() - data_time
            if data_time &gt; self.data_time and self.ir:
                self.data_time = data_time
                print 'data time', self.data_time
            # self.out_buff = np.append(self.out_buff, np.zeros(self.k))
            self.out_buff = np.append(self.out_buff, self.in0_buff[:self.k])
            self.out_buff = np.append(self.out_buff, self.in0_buff[self.k: self.fs] - np.dot(A, self.h))
            self.out_num += self.fs
            self.in0_buff = self.in0_buff[self.fs - self.k:]  # keep last 2k samples for next time
            self.in1_buff = self.in1_buff[self.fs - self.k:]  # keep last 2k samples for next time
            self.fc += 1
            self.first = 0

        # generate output...
        out_len = len(output_items[0])
        if self.out_num &gt;= out_len:
            # print 'full'
            output_items[0][:] = self.out_buff[:out_len]
            self.out_buff = self.out_buff[out_len:]
            self.out_num -= out_len
        elif self.out_num &gt; 0:
            # print 'some empty'
            output_items[0][:self.out_num] = self.out_buff[:self.out_num]
            self.out_buff = self.out_buff[self.out_num:]
            out_len = self.out_num
            self.out_num = 0
        else:  # self.out_num == 0
            # print 'empty'
            output_items[0] = np.zeros(out_len)
            # out_len = 0

        if not(self.fc % 19) and self.ir:
            print 'SIC time = ', (time.time() - t)

        return out_len


def find_h_np(k, p, y, x, wr=0):
    # build matrix A from x (the transmitted signal)
    A = build_A(x[: p], k)
    # build weights vector h from matrix A and y (the received signal)
    # the beginning of the first input stream is (k + 1) the end is (k + 1 + 2k)
    h = np.linalg.lstsq(A, y[k: p - k])[0]
    if np.linalg.LinAlgError and wr:
        print 'Warn: Least Squares Alg did not converge!'

    return h


def build_A(x, k):
    n = len(x) - 2 * k
    A = np.zeros((n, 2 * k), dtype=np.complex64)

    # A[0,0]...A[0,2k-1] = x[0].....x[2k-1]
    # A[1,0]...A[1,2k-1] = x[1].....x[1 + 2k-1]
    # ......................................
    # A[n-1,0]...A[1,2k] = x[n-1]...x[n-1 + 2k-1]
    for i in range(0, n):
        A[i, :] = x[i: i + 2 * k]
    return A
</value></param>
<param><key>error_report</key><value>1</value></param>
<param><key>frame_size</key><value>frame_size</value></param>
<param><key>frames</key><value>frames</value></param>
<param><key>information_report</key><value>0</value></param>
<param><key>k</key><value>k</value></param>
<param><key>preamble_size</key><value>pream_size</value></param>
<param><key>warning_report</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>func_power_diff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr


class power_ratio(gr.sync_block):
    def __init__(self, sample_rate=1e6, samples_per_symbole=8, fft_size=0.5e6, display=1, display_rate=1):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Power Ratio',
            in_sig=[np.complex64, np.complex64],
            out_sig=[]

        )
        # self.fft_size = int(sample_rate)
        self.fft_size = int(fft_size)
        self.fft0_buffer = []
        self.fft1_buffer = []
        self.bw = int(sample_rate / samples_per_symbole)
        self.half = int(self.bw / 2)
        self.display = display
        self.disp_r = display_rate

        self.sum_fft0 = 0
        self.sum_fft1 = 0
        self.times = 0

    def work(self, input_items, output_items):

        self.fft0_buffer = np.append(self.fft0_buffer, input_items[0])
        self.fft1_buffer = np.append(self.fft1_buffer, input_items[1])
        # print len(self.fft_buffer), len(input_items[0]), self.fft_size

        if len(self.fft0_buffer) &gt;= self.fft_size and len(self.fft1_buffer) &gt;= self.fft_size:
            fft0 = np.fft.fft(self.fft0_buffer[:self.fft_size]) / self.fft_size
            fft1 = np.fft.fft(self.fft1_buffer[:self.fft_size]) / self.fft_size
            self.fft0_buffer = self.fft0_buffer[self.fft_size:]
            self.fft1_buffer = self.fft1_buffer[self.fft_size:]

            fft0_avg = (np.sum(np.absolute(fft0[:self.half])) + np.sum(np.absolute(fft0[-self.half:]))) / self.bw
            fft1_avg = (np.sum(np.absolute(fft1[:self.half])) + np.sum(np.absolute(fft1[-self.half:]))) / self.bw

            if fft0_avg == 0 or fft1_avg == 0:
                return len(input_items[0])

            self.times += 1

            fft0_avg_db = 20 * np.log10(fft0_avg)
            fft1_avg_db = 20 * np.log10(fft1_avg)

            self.sum_fft0 += fft0_avg_db
            self.sum_fft1 += fft1_avg_db

            if self.times % self.disp_r == 0 and self.display:
                avg0 = self.sum_fft0 / self.times
                avg1 = self.sum_fft1 / self.times
                ratio = avg0 - avg1
                print 'Power Ratio: %0.2f [dB]' % ratio

        return len(input_items[0])
</value></param>
<param><key>display_rate</key><value>1</value></param>
<param><key>display</key><value>power_ratio_display</value></param>
<param><key>fft_size</key><value>0.5e6</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>samples_per_symbole</key><value>sps</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>func_print_msg</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr

class print_fd_message(gr.sync_block):
    def __init__(self, display=0):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Print FD Message',
            in_sig=[np.uint8],
            out_sig=[]
        )
        self.disp = display
        self.count = 0

    def work(self, input_items, output_items):

        in_size = len(input_items[0])

        if self.disp:
            start = 0
            for i in range(0, in_size):
                if input_items[0][i] == 10:
                    stop = i + 1
                    self.count += 1
                    print self.count, ': ', input_items[0][start:stop].tobytes()
                    start = i + 1

        return len(input_items[0])
</value></param>
<param><key>display</key><value>fd_message_display</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>func_relative_path</value></param>
<param><key>source_code</key><value>import os

script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>900e6</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>SIC In TX</value></param>
<param><key>label2</key><value>SIC Out</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>usrp_sink</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>sic_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0</value></param>
<param><key>stream_id</key><value>sic_in_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0</value></param>
<param><key>stream_id</key><value>sic_in_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>sic_in_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>sic_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>sic_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>sic_in_rx</value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>func_print_msg</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0_0_0</source_block_id><sink_block_id>digital_psk_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>func_dig_sic</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0_0_0</source_block_id><sink_block_id>func_dig_sic</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0_0_0</source_block_id><sink_block_id>virtual_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>func_desired_msg</source_block_id><sink_block_id>blks2_packet_encoder_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>func_dig_sic</source_block_id><sink_block_id>digital_psk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>func_dig_sic</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>func_power_diff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>func_power_diff</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
