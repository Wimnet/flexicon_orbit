<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_txrx_psk_spectrum</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>att_code</value></param>
<param><key>value</key><value>32</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>127</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_usrp_in</value></param>
<param><key>value</key><value>"usrp_in"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_usrp_out</value></param>
<param><key>value</key><value>"usrp_out"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>900e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_code</value></param>
<param><key>value</key><value>120</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>255</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_addr</value></param>
<param><key>value</key><value>"type=usrp2"</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>uhd_usrp_sink_0</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.0)</value></param>
<param><key>function_name</key><value>set_time_now</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0</value></param>
<param><key>block_id</key><value>uhd_usrp_sink_0</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.5)</value></param>
<param><key>function_name</key><value>set_start_time</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0_0</value></param>
<param><key>block_id</key><value>uhd_usrp_source_0</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.5)</value></param>
<param><key>function_name</key><value>set_start_time</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_1</value></param>
<param><key>block_id</key><value>uhd_usrp_source_0</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.0)</value></param>
<param><key>function_name</key><value>set_time_now</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>file_usrp_out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>file_usrp_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>func_relative_path</value></param>
<param><key>source_code</key><value>import os

script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>subdev_sub20_init</key>
<param><key>id</key><value>subdev_sub20_init_0</value></param>
<param><key>atten_code</key><value>int(att_code)</value></param>
<param><key>phase_code</key><value>int(phase_code)</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>usrp_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>usrp_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
