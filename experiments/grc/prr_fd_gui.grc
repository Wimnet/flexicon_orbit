<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>prr_fd_gui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>-21.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0,1,6</value></param>
<param><key>label</key><value>BB Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-25</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>-21.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay_tx2rx</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>((packet_len+4)/12+3+2 + 2 + 2*2)*80  + 0*80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers_len</value></param>
<param><key>value</key><value>len(occupied_carriers[0])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad_front_len</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pad_tail_len</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers_len</value></param>
<param><key>value</key><value>len(pilot_carriers[0])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols_len</value></param>
<param><key>value</key><value>len(pilot_symbols[0])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>premultiply</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_num</value></param>
<param><key>value</key><value>(packet_len + 4)*8/2 /occupied_carriers_len + 3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word_len</value></param>
<param><key>value</key><value>len(sync_word)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word_zero_len</value></param>
<param><key>value</key><value>len(sync_word_zeros)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word_zeros</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>5,0,1,6</value></param>
<param><key>label</key><value>Tx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_sink_addr</value></param>
<param><key>value</key><value>"addr0=192.168.30.3, addr1=192.168.30.4"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_source_addr</value></param>
<param><key>value</key><value>"addr0=192.168.30.3, addr1=192.168.30.4"</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0_0_0</value></param>
<param><key>block_id</key><value>uhd_usrp_source</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.5)</value></param>
<param><key>function_name</key><value>set_start_time</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0_1</value></param>
<param><key>block_id</key><value>uhd_usrp_sink</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.5)</value></param>
<param><key>function_name</key><value>set_start_time</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_1_0</value></param>
<param><key>block_id</key><value>uhd_usrp_source</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.0)</value></param>
<param><key>function_name</key><value>set_time_now</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_2</value></param>
<param><key>block_id</key><value>uhd_usrp_sink</value></param>
<param><key>function_args</key><value>uhd.time_spec_t(0.0)</value></param>
<param><key>function_name</key><value>set_time_now</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1e-9</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>50</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>51</value></param>
<param><key>num_samps</key><value>50</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_float_to_uchar</key>
<param><key>id</key><value>blocks_float_to_uchar_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply * 10 ** (-5.0/20)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.01*2.23 * 0.56 * 1.4 * 1.4 * premultiply * 10**(bb_gain/20.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_3</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_3_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_3_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_3_1_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_0</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>packet_len</key><value>frame_len + pad_front_len + pad_tail_len</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0_0_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"rx_len_tag_key"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>rolloff</key><value>0</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0_0_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>rolloff</key><value>0</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>fullduplex_async_divide</key>
<param><key>id</key><value>fullduplex_async_divide_0</value></param>
</block>
<block>
<key>fullduplex_count_packets</key>
<param><key>id</key><value>fullduplex_count_packets_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>fullduplex_count_packets</key>
<param><key>id</key><value>fullduplex_count_packets_0_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>fullduplex_digital_sic</key>
<param><key>id</key><value>fullduplex_digital_sic_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_tx2rx</key><value>delay_tx2rx</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>pad_front</key><value>pad_front_len</value></param>
<param><key>premultiplier</key><value>premultiply</value></param>
<param><key>si_chan_dim</key><value>1</value></param>
<param><key>si_chan_k</key><value>10</value></param>
<param><key>sig_pilot_pos</key><value>0</value></param>
</block>
<block>
<key>fullduplex_ofdm_constellation</key>
<param><key>id</key><value>fullduplex_ofdm_constellation_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_tx2rx</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>packet_len</key><value>frame_len</value></param>
<param><key>pad_front</key><value>-20</value></param>
</block>
<block>
<key>fullduplex_ofdm_constellation</key>
<param><key>id</key><value>fullduplex_ofdm_constellation_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_tx2rx</key><value>8</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>packet_len</key><value>frame_len</value></param>
<param><key>pad_front</key><value>-20</value></param>
</block>
<block>
<key>fullduplex_packet_encap2</key>
<param><key>id</key><value>fullduplex_packet_encap2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>pad_front</key><value>pad_front_len</value></param>
<param><key>sig_pilot_pos</key><value>0</value></param>
<param><key>pad_tail</key><value>pad_tail_len</value></param>
<param><key>premultiplier</key><value>premultiply</value></param>
<param><key>sync_word</key><value>2</value></param>
</block>
<block>
<key>fullduplex_packet_encap2</key>
<param><key>id</key><value>fullduplex_packet_encap2_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>pad_front</key><value>pad_front_len</value></param>
<param><key>sig_pilot_pos</key><value>1</value></param>
<param><key>pad_tail</key><value>pad_tail_len</value></param>
<param><key>premultiplier</key><value>0.2</value></param>
<param><key>sync_word</key><value>2</value></param>
</block>
<block>
<key>fullduplex_snr_calc</key>
<param><key>id</key><value>fullduplex_snr_calc_0</value></param>
<param><key>data_symbols</key><value>6</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_txrx</key><value>0</value></param>
<param><key>noise_length</key><value>140</value></param>
<param><key>noise_start_idx</key><value>0</value></param>
<param><key>pad_front</key><value>-20</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>3, 7, 3, 3</value></param>
<param><key>name</key><value>"Constellation after Digital SIC"</value></param>
<param><key>size</key><value>3*48</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>0, 7, 3, 3</value></param>
<param><key>name</key><value>"Constellation after RF SIC"</value></param>
<param><key>size</key><value>3*48</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>3,0,1,6</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>"Signal-to-Noise Ratio"</value></param>
<param><key>unit1</key><value>"dB"</value></param>
<param><key>max</key><value>35</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Measured SNR"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,6</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>35</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Transmitted Packets"</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,6</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>35</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Received Packets"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_0_0</value></param>
<param><key>gui_hint</key><value>4,0,1,6</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>"Packet Reception  Ratio"</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Measured PRR"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0,3,6</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"After RF SIC, I"</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"After RF SIC, Q"</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>"After Digital SIC, I"</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>"After Digital SIC, Q"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>frame_len</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>usrp_sink_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>freq</value></param>
<param><key>dc_offs_enb1</key><value>True</value></param>
<param><key>iq_imbal_enb1</key><value>True</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>usrp_source_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>fd_tx_stream</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>fd_tx_stream</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_float_to_uchar_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_uchar_0</source_block_id><sink_block_id>fullduplex_count_packets_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>fullduplex_packet_encap2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>fullduplex_packet_encap2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_ofdm_tx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_0</source_block_id><sink_block_id>fullduplex_count_packets_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>fullduplex_digital_sic_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_async_divide_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_count_packets_0</source_block_id><sink_block_id>blocks_null_sink_3_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fullduplex_count_packets_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_count_packets_0</source_block_id><sink_block_id>fullduplex_async_divide_0</sink_block_id><source_key>out_msg</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>fullduplex_count_packets_0_0</source_block_id><sink_block_id>blocks_null_sink_3_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_count_packets_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_count_packets_0_0</source_block_id><sink_block_id>fullduplex_async_divide_0</sink_block_id><source_key>out_msg</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>blocks_null_sink_3_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>fullduplex_ofdm_constellation_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>digital_ofdm_rx_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>fullduplex_ofdm_constellation_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>fullduplex_snr_calc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fullduplex_digital_sic_0_0</source_block_id><sink_block_id>blocks_null_sink_3</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_ofdm_constellation_0</source_block_id><sink_block_id>blocks_null_sink_3_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fullduplex_ofdm_constellation_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_ofdm_constellation_0_0</source_block_id><sink_block_id>blocks_null_sink_3_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_ofdm_constellation_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_packet_encap2_0</source_block_id><sink_block_id>uhd_usrp_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_packet_encap2_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fullduplex_packet_encap2_0_0</source_block_id><sink_block_id>uhd_usrp_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fullduplex_snr_calc_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>fullduplex_digital_sic_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
